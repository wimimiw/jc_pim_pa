# Keil uVision project rf_module.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rf_module
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER
  c include: ..\app;..\device;..\driver\inc;..\driver;..\cpu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group app
    ../app/: main.c rf_control.c rf_protocol.c rf_parameter.c task.c target.c stm32f10x_it.c system_stm32f10x.c
  group device
    ../device/: dev_spi.c dev_att.c dev_e2prom.c dev_temp.c
  group driver
    ../driver/: user_timer.c user_adc.c user_i2c.c user_uart.c user_flash.c
    ../driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c
  group cpu
    ../cpu/: core_cm3.c startup_stm32f10x_md_vl.s
target Release (ARM-ADS)
  device: STM32F100V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rf_module +hex
  AfterMake: mdkConv.exe     \release\output\rf_module.hex  ..\[fw].-.[jc_switch_matrix]
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER,WATCHDOG_EN
  c include: ..\app;..\device;..\driver\inc;..\driver;..\cpu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\release\output\rf_module.sct
  link misc: --keep user_flash.o(BOOTLOADER)  --keep stm32f10x_flash.o(.text) --keep stm32f10x_iwdg.o(.text)
