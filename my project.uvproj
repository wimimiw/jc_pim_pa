# Keil uVision project my project.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC932 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: test +hex
  AfterMake: .\output\conv_v2.exe .\output\test.hex -32 -R .\output\ZGRF_V30
  c flags: Optimize=9
  c include: .\APP;.\drive;.\LPC900
  group APP
    ./APP/: main.c timer.c bro20W_cpu.c bro20W_RFcontrol.c bro20W_packet.c
    ./LPC900/: START900.A51
  group drive
    ./drive/: I2C.c SPI.C e2prom.c serial.c
